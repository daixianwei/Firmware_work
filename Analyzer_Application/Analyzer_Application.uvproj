# Keil uVision project Analyzer_Application.uvproj, settings and files
target Analyzer_Application (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Analyzer_Application +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c misc: --diag_suppress=870
  c include: .\System\CM3;.\System\FWlib\inc;.\System\Startup;.\ISR;.\Main;.\Management\DisplayDriver;.\Management\HumanInput;.\Management\Interface;.\Management\RotationMotor;.\Management\ScanMotor;.\Management\Common_CRC;.\Management\QRCode;.\Management\SystemManage_RTC;.\Management\SignalProcess_Sample;.\USB;.\USB\comm;.\USB\lib;.\USB\src;.\USB\USB_Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0xfffc
  group System
    ./System/CM3/: core_cm3.c system_stm32f10x.c
    ./System/Startup/: startup_stm32f10x_hd.s
    ./System/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Main
    ./Main/: main.c
  group ISR
    ./ISR/: stm32f10x_it.c
  group Management
    ./Management/RotationMotor/: RotationMotor.c RotationMotorDriver_PositionSensor.c
    ./Management/DisplayDriver/: DisplayDriver.c DisplayDriver_FontLib.c Font.c
    ./Management/HumanInput/: HumanInput.c
    ./Management/Interface/: Interface_main.c Interface_Standard.c Interface_Quick.c Interface_Record.c Interface_Setting.c Interface_Result.c Interface_Start.c Interface_Testing.c Interface_Result_2.c Interface_Insert_Cup.c
    ./Management/ScanMotor/: ScanMotorDriver.c ScanMotorDriver_PositionSensor.c
    ./Management/Common_CRC/: Common.c
    ./Management/QRCode/: QRCode.c
    ./Management/SystemManage_RTC/: SystemManage_RTC.c
    ./Management/SignalProcess_Sample/: SignalProcess_Sample.c
  group USB
    ./USB/comm/: Comm_FIFO.c
    ./USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ./USB/USB_Communication/: stmflash.c USB.c HostComm.c
    ./USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
